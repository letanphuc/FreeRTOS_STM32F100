# Keil uVision project freeRTOS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: freeRTOS
  c flags: Optim=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER, USE_STM32_DISCOVERY
  c include: ..\User;..\Utilities\STM32_EVAL\STM32_Discovery;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\FreeRTOS_Source\include;..\FreeRTOS_Source\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ../User/: system_stm32f10x.c stm32f10x_it.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: cortexm3_macro_rvds.s misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group User
    ../User/: main.c debug.c realtimer.c
  group Free RTOS files
    ../FreeRTOS_Source/: croutine.c list.c queue.c tasks.c timers.c
    ../FreeRTOS_Source/portable/MemMang/: heap_2.c
    ../FreeRTOS_Source/portable/RVDS/ARM_CM0/: port.c
  group Utinities
    ../Utilities/STM32_EVAL/STM32_Discovery/: STM32vldiscovery.c
